NETWORK_MANAGER = "networkmanager"
