PROVIDES = "udev libudev"
